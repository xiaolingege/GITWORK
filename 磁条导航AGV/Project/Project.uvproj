# Keil uVision project Project.uvproj, settings and files
target 神舟III号 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SZ_STM32F103ZE_DEMO +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\;.\..\Libraries\CMSIS\CM3\CoreSupport;.\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\Utilities\STM32_EVAL;.\..\Utilities\STM32_EVAL\Common;.\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\BSP;..\algotithm;..\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: stm32f10x_it.c main.c xprintf.c SZ_STM32F103ZE_LIB.c
  group StdPeriph_Driver
    ./../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c
  group CMSIS
    ./../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK_start_code
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/TrueSTUDIO/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/: rs485config.c hardware.c rs485communicate.c
  group algorithm
    ../algotithm/: magserv.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
